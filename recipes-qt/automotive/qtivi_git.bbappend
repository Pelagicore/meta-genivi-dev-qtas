# Make sure DLT is available to enable geniviextras
DEPENDS += "dlt-daemon"
