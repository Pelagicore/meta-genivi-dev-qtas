# Fix QA failure that file is installed but not shipped
FILES_${PN} += "/usr/lib/qt5/qml/QtQuick/Dialogs/qml/icons.ttf"
