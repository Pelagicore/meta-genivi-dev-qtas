RDEPENDS_packagegroup-abstract-component-p1_remove = "weston weston-examples"
