FILESEXTRAPATHS_append := "${THISDIR}/${PN}"

SRC_URI += "file://0001-Adapt-patch-from-https-bugreports.qt.io-browse-QTBUG.patch"
#SRC_URI += "file://remove-touch-focus-2.patch"
