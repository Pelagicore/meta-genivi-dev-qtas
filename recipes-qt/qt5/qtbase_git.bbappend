PACKAGECONFIG_append += "kms eglfs dbus widgets openssl udev jpeg libpng pulseaudio evdev"
