RDEPENDS_packagegroup-gdp-qt5_remove = "qtbase-fonts qtbase-fonts qtbase-fonts-pfa qtbase-fonts-pfb qtbase-fonts-qpf qtbase-fonts-ttf-dejavu qtbase-fonts-ttf-vera"
