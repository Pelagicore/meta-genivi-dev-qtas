SRCREV_qtwebengine = "61e35009aa276e9d2d7ff1787b52ba06f8cde37f"
SRCREV_chromium = "853d4069e45b06106f33611c458f5480f71e7c57"

QT_MODULE_BRANCH = "5.9"
